# IAR project Project.ewp, settings and files
configuration STM32H747-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_M7 ST STM32H747XI_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H747xx; CORE_CM7; USE_STM32H747I_DISCO; EW_USE_FREE_RTOS=1; _EW_USE_EXTERNAL_FLASH=1; _EW_BITMAP_PIXEL_SECTION_NAME=.SectionEwResource; _EW_FONT_PIXEL_SECTION_NAME=.SectionEwResource; EW_SURFACE_ROTATION=0; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers\CMSIS\Include; ..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers\BSP\STM32H747I-DISCO; ..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers\BSP\Components\Common; ..\..\Source; ..\..\..\TargetSpecific; ..\..\..\TargetSpecific\Drivers; ..\..\GeneratedCode; ..\..\..\PlatformPackage\RTE; ..\..\GeneratedCode\EmWiGfxInclude; ..\..\..\ThirdParty\STM32Cube_FW_H7\MiddleWares\Third_Party\FreeRTOS\Source\include; ..\..\..\ThirdParty\STM32Cube_FW_H7\MiddleWares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\ThirdParty\STM32Cube_FW_H7\MiddleWares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Source
  OBJCOPY.OOCOutputFile: EmbeddedWizard-STM32H747-Discovery.hex
  ILINK.IlinkOutputFile: EmbeddedWizard-STM32H747-Discovery.out
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../GeneratedCode/: ewfiles.ipcf
  group Application
    ../../Source/: DeviceDriver.c ewconfig.h ewmain.c main.c
    ./: startup_stm32h747xx.s
  group Application/TargetSpecific
    ../../../TargetSpecific/: ew_bsp_clock.c ew_bsp_console.c ew_bsp_display.c ew_bsp_event.c ew_bsp_graphics.c ew_bsp_inout.c ew_bsp_system.c ew_bsp_touch.c stm32h7xx_it.c system_stm32h7xx.c
  group Application/TargetSpecific/Drivers
    ../../../TargetSpecific/Drivers/: ft6x06.c ft6x06_reg.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../ThirdParty/STM32Cube_FW_H7/Drivers/BSP/Components/is42s32800j/: is42s32800j.c
    ../../../ThirdParty/STM32Cube_FW_H7/Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
    ../../../ThirdParty/STM32Cube_FW_H7/Drivers/BSP/Components/otm8009a/: otm8009a.c otm8009a_reg.c
  group Drivers/BSP/STM32H747B_Discovery
    ../../../ThirdParty/STM32Cube_FW_H7/Drivers/BSP/STM32H747I-DISCO/: stm32h747i_discovery.c stm32h747i_discovery_bus.c stm32h747i_discovery_lcd.c stm32h747i_discovery_qspi.c stm32h747i_discovery_sdram.c
  group Drivers/STM32FHxx_HAL_Driver
    ../../../ThirdParty/STM32Cube_FW_H7/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_ll_fmc.c
  group EmbeddedWizard/GeneratedCode
    ../../GeneratedCode/: _ApplicationBall.h _ApplicationCross.h _ApplicationFontLarge.h _ApplicationFontSmall.h Application.c Core.c Effects.c Graphics.c Resources.c Views.c
  group EmbeddedWizard/RGB565
    ../../../PlatformPackage/RGB565/: ewextbmp_RGB565.c ewextfnt.c ewextgfx.c ewextpxl_RGB565.c ewgfx.c ewgfxattrtext.c ewgfxbidi.c ewgfxcore.c ewgfxdriver.c ewgfxtasks.c
  group EmbeddedWizard/RTE
    ../../../PlatformPackage/RTE/: ewcolor.c ewdebug.c ewextrte.c ewheap.c ewobject.c ewpoint.c ewrect.c ewref.c ewresource.c ewscalars.c ewslot.c ewstring.c ewtimer.c
  group FreeRTOS
    ../../../ThirdParty/STM32Cube_FW_H7/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../ThirdParty/STM32Cube_FW_H7/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../ThirdParty/STM32Cube_FW_H7/Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/STM32Cube_FW_H7/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
